# Keil uVision project iap_boot.uvprojx, settings and files
target iap_boot_Release (6100001::V6.10.1::.\ARMCLANG)
  device: HC32L021C8PB HDSC
  pack: HDSC.HC32L02x.1.1.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: iap_boot +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\common;..\source;..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l021.s
    ../common/: interrupts_hc32l021.c system_hc32l021.c
  group source
    ../source/: main.c iap.c modem.c config_hc32l021.c boot_param.c
  group driver
    ../driver/src/: hsi2c.c ddl.c sysctrl.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
